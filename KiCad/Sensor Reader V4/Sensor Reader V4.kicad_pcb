# Repository Inverated/Proa-II-Electrical-Setup

## KiCad design KiCad/Sensor Reader V4/Sensor Reader V4.kicad_pcb

Board: 2 copper layers, 51.5 x 63.0 mm, 67 parts (0 on the bottom side), 41 nets.

Parts:
C2, C4, C7, C9, C10, C13: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C8, C12, C20, C23: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C14, C15, C16, C17, C18, C19, C21, C22: 4.7nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
IC1: TLV76733DGNR; SOP65P490X110-9N
IC2: ESP32-C3-WROOM-02-H4; ESP32C3WROOM02H4
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J2: GPIO; PinHeader_1x03_P2.54mm_Vertical
J6: Exposed_UART; PinHeader_1x06_P2.54mm_Vertical
J7: Batt1_V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: Batt2_V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: M_OUT/B1_In; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: L_I/B1_Out; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: B1_Net/B2_In; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: B2_Net/B2_Out; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J13: AIN_4; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J14: AIN_5; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J15: 5V_Input; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J16: 3.3V_Output; PinHeader_1x02_P2.54mm_Vertical
R2, R20: 5.1KΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6, R7: 10kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R10, R11, R12, R13, R14, R15: 1kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R18: 100kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R19: 20kΩ; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: BOOT_Btn; TS0266100BK100LCRD
SW2: EN_Btn; TS0266100BK100LCRD
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_D1.0mm
U3: ADS8688; SOP50P640X120-38N

Connections:
+3.3V: C3.1, C6.1, C11.1, C13.1, C23.1, IC1.1 (OUT), IC1.2 (SNS), IC2.1 (3V3), J16.2, R3.1, R4.1, R5.1, R6.1, R7.2, TP1.1 (1_1), U3.34 (DVDD)
+5V: C2.1, C9.1, C10.1, C12.1, C20.1, IC1.5 (EN), IC1.8 (IN), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J6.4, J15.2, TP3.1 (1_1), U3.9 (AVDD), U3.30 (AVDD)
AIN_4: J13.2, R12.1
AIN_5: J14.2, R13.1
BOOT: IC2.8 (IO9), J6.6, R4.2, SW1.1, SW1.2
Batt1_Net/Batt2_In: J11.2, R10.1
Batt1_V: J7.2, R16.1
Batt2_Net/Batt2_Out: J12.2, R11.1
Batt2_V: J8.2, R18.1
CS: IC2.6 (IO7), TP4.1 (1_1), U3.38 (~CS)
EN: C4.1, IC2.2 (EN), J6.5, R3.2, SW2.1, SW2.2
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.2, C21.1, C22.1, C23.2, IC1.4 (GND_1), IC1.6 (GND_2), IC1.9 (EP), IC2.9 (GND_1), IC2.19 (GND_2), IC2.20 (GND_3), IC2.21 (GND_4), IC2.22 (GND_5), IC2.23 (GND_6), IC2.24 (GND_7), IC2.25 (GND_8), IC2.26 (GND_9), IC2.27 (GND_10), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, R2.1, R17.2, R19.2, R20.2, SW1.3 (K), SW1.4 (A), SW2.3 (K), SW2.4 (A), TP2.1 (1_1), TP8.1 (1_1), U3.3 (DAISY), U3.4 (~REFSEL), U3.6 (REFGND), U3.8 (AGND), U3.10 (AUX_IN), U3.11 (AUX_GND), U3.13 (AIN_6GND), U3.15 (AIN_7GND), U3.17 (AIN_0GND), U3.19 (AIN_1GND), U3.20 (AIN_2GND), U3.22 (AIN_3GND), U3.24 (AIN_4GND), U3.26 (AIN_5GND), U3.28 (AGND), U3.29 (AGND), U3.31 (AGND), U3.32 (AGND), U3.33 (DGND)
GPIO0: IC2.18 (IO0), J2.1
GPIO1: IC2.17 (IO1), J2.2
GPIO10: IC2.10 (IO10), J2.3
Load_In/Batt1_Out: J10.2, R9.1
MPPT_Out/Batt1_In: J9.2, R8.1
unnamed: IC2.16 (IO2), R5.2
unnamed: IC2.7 (IO8), R6.2
unnamed: J1.A5 (CC1), R2.2
unnamed: J1.B5 (CC2), R20.1
unnamed: R14.1, R16.2, R17.1
unnamed: R15.1, R18.2, R19.1
unnamed: C21.2, R8.2, U3.16 (AIN_0P)
unnamed: C22.2, R9.2, U3.18 (AIN_1P)
unnamed: C17.2, R10.2, U3.21 (AIN_2P)
unnamed: C18.2, R11.2, U3.23 (AIN_3P)
unnamed: C19.2, R12.2, U3.25 (AIN_4P)
unnamed: C14.2, R13.2, U3.27 (AIN_5P)
unnamed: C15.2, R14.2, U3.12 (AIN_6P)
unnamed: C16.2, R15.2, U3.14 (AIN_7P)
unnamed: C7.1, C8.1, U3.7 (REFCAP)
unnamed: C5.1, U3.5 (REFIO)
RST: IC2.15 (IO3), R7.1, U3.2 (~RST/PD)
RX: IC2.11 (RXD), J6.2
SCLK: IC2.5 (IO6), TP5.1 (1_1), U3.37 (SCLK)
SDI: IC2.4 (IO5), TP6.1 (1_1), U3.1 (SDI)
SDO: IC2.3 (IO4), TP7.1 (1_1), U3.36 (SDO)
TX: IC2.12 (TXD), J6.3
USB_D+: IC2.14 (IO19), J1.A6 (D+), J1.B6 (D+)
USB_D-: IC2.13 (IO18), J1.A7 (D-), J1.B7 (D-)

File KiCad/Sensor Reader V4/jlcpcb/production_files/BOM-Sensor Reader V4.csv:

Comment,Designator,Footprint,LCSC,Quantity
100kΩ,"R16,R18",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25803,2
100nF,C6,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,1
10kΩ,"R3,R4,R5,R6,R7",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804,5
10uF,C23,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,1
10uF,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,1
10uF,"C11,C12,C20,C5",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C57112,4
1kΩ,"R10,R11,R12,R13,R14,R15,R8,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C21190,8
1uF,C4,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,1
1uF,C7,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,1
1uF,"C13,C2",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C16780,2
1uF,"C10,C9",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C57112,2
20kΩ,"R17,R19",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C4184,2
4.7nF,"C14,C15,C16,C17,C18,C19,C21,C22",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C53987,8
4.7uF,C3,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C19666,1
5.1Ω,"R1,R2",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25197,2
ADS8688,U3,SOP50P640X120-38N,C2670630,1
ESP32-C3-WROOM-02-H4,IC2,ESP32C3WROOM02H4,C2944070,1
TestPoint,TP2,TestPoint_Pad_D1.0mm,,1
TestPoint,TP1,TestPoint_Pad_D1.0mm,,1
TLV76733DGNR,IC1,SOP65P490X110-9N,,1
AIN_4,AIN_4,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
Exposed_UART,J6,PinHeader_1x06_P2.54mm_Vertical,,1
TestPoint,TP8,TestPoint_Pad_D1.0mm,,1
EN_Btn,SW2,TS0266100BK100LCRD,,1
BOOT_Btn,SW1,TS0266100BK100LCRD,,1
L_I/B1_Out,Load_In/B1_Out,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
UJ20-C-H-G-MSMT-2B-P16-TR,J2,UJ20CHGMSMT2BP16TR,,1
TestPoint,CS,TestPoint_Pad_D1.0mm,,1
TestPoint,SDO,TestPoint_Pad_D1.0mm,,1
TestPoint,TP3,TestPoint_Pad_D1.0mm,,1
M_OUT/B1_In,MPPT_Out/B1_In,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
Batt2_V,Batt2_V,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
Batt1_V,Batt1_V,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
5V_Input,5V_In,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
B1_Net/B2_In,B1_Net/B2_In,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
B2_Net/B2_Out,B2_Net/B2_Out,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
AIN_5,AIN_5,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,,1
TestPoint,SDI,TestPoint_Pad_D1.0mm,,1
3.3V_Output,J16,PinHeader_1x02_P2.54mm_Vertical,,1
TestPoint,SCLK,TestPoint_Pad_D1.0mm,,1

## Commit log (part)

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2026-01-01 Init
2026-01-08 Fix wiring check issue
2026-01-10 mppt integration test code
2026-01-10 update lib location
    copy library to local path instead of using github as reference location
2026-01-11 exclude text from sim
2026-01-12 setup kicad5 for skidl
2026-01-12 KiCad_Skip & Schemdraw test
2026-01-14 Complete MPPT+HE reading
    Reading works for arduino and esp8266
2026-01-15 Setup pyspice
2026-01-17 Pyspice setup for single mppt
    MPPT spice formula generated using chatgpt (Not working properly). Fix once proper understanding. Remaining code understandable (draw it out)
2026-01-17 Adding multiple MPPT array (WIP)
2026-01-17 Refactor test2.py circuit setup and simplify requirements
    Updated test2.py to improve circuit modeling: adjusted battery and MPPT parameters, restructured node connections, added DC bus and capacitor, and refined load and wiring logic. requirements.txt is n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
2026-01-18 Fix mppt output
    Simulation is working.
    Next: Implement battery input and output current limit.
2026-01-18 Restrict current output of mppt
2026-01-18 Implemented battery charge and discharge limit
2026-01-18 Fix discharge limit calculation for multiple mppt
2026-01-19 Fixed restriction
    Fix battery charge and discharge limit
2026-01-19 setup json reading
2026-01-19 read from json
2026-01-19 Remove unused imports
2026-01-19 Update result display
2026-01-20 refactor simlation res
2026-01-20 Save simulation to json file
2026-01-20 Refactor out result parsing
2026-01-20 Completed warning message and refactor json output
2026-01-22 Setup sweeping graph result
2026-01-22 Implemented 0 mppt array setup
2026-01-22 reduce graph marker size
2026-01-25 Initialise sender module for digital twin test
2026-01-25 Untested receiver module
2026-01-26 SoC receiver module tracker
2026-01-26 Complete simulator
    Lots of wire issues
2026-01-27 update result output format
2026-01-27 implemented solar panel output sweep
2026-01-27 Restore schemdraw circuit generator
2026-01-27 solar-mppt initial setup
2026-01-28 Generalise schemdraw array function
2026-01-28 Relocate readme
2026-01-28 Seperate simulation graph save
2026-01-29 Amend receiver mac address
2026-01-29 Fix load power
2026-01-29 Fix load powerC:/Users/Kor/Documents/GitHub/Proa-II-Electrical-Setup/venv/Scripts/python.exe
2026-01-29 Refactor __main__ function
2026-01-29 Modify result json functionality
2026-01-29 Reorder function parameter
2026-01-29 Setup time based voyage sweep (Untested)
2026-02-01 voyage sweep fix
2026-02-01 Complete time block simulation
2026-02-01 Fix current conversion calculation
2026-02-01 I dont get it
2026-02-02 Fix battery charge polarity
2026-02-02 Fixing incorrect soc calculation (Exceed 100%)
2026-02-02 temp
2026-02-03 Fixed voyage sweep graph
2026-02-03 Fix plot point
2026-02-03 Fix voltage spike
2026-02-03 Implemented Kirchhoff's current law test
2026-02-04 Refactor component name
2026-02-16 Complete electrical diagram
2026-02-24 new code
2026-02-24 Completed transmission and reading data
    Have not setup uart reading
2026-02-25 sensor reading data
2026-03-04 add excel calibration
2026-03-07 update kicad design
2026-03-08 v3 sensor code
2026-03-09 Update sensor and server code
2026-03-10 Implement local server discovery
2026-03-10 Basic real time update with EventSource
2026-03-11 test
2026-03-16 Sensor v4
2026-03-18 Update sch
2026-03-18 Data recoding
2026-03-18 Calibrate readings
2026-03-19 setup template website
2026-03-19 implemented multiple graphs
2026-03-19 Update kicad electrical schematics drawing
2026-03-21 data cleaning for rc fitting
2026-03-22 completed curve fitting
2026-03-25 completed reading 2
2026-04-01 data loggin 3
2026-04-04 partial cleaning
2026-04-08 Final discharging data
2026-04-15 Reading
2026-04-16 calibration setup 2
2026-04-18 Clean data 2
2026-05-03 new schematic v4
2026-05-04 v4_jlc test edition
2026-05-04 custom perf hole footprint
2026-05-05 finish populating components
2026-05-05 edge cut
2026-05-06 data coll
2026-05-06 coll2
2026-05-07 transfer recorded data
2026-05-08 RC MEASUREMENT
2026-05-08 KICAD pcb
2026-05-09 final pcb design
2026-05-11 Arrange files
2026-05-11 consolidatte current annd voltage data
2026-05-11 calibrate voltage and current 2
2026-05-11 calibration shortlisting
2026-05-12 ocv_soc fitt
2026-05-13 rc model fitted
2026-05-13 more fitting
2026-05-13 rearrange
2026-05-14 rc discharge data complete
2026-05-14 more data logging and cleaning
2026-05-14 more data calibration on completed recording
2026-05-18 Updated missing columns from lookup table
2026-05-18 new constant calculation code
2026-05-18 new constants variable
2026-05-18 new calibration data
2026-05-21 3d modeled?
2026-05-22 data collection
2026-05-22 fix speed
2026-05-23 stupid header sync shit
2026-05-23 Continuous checksum
2026-05-23 studpid esp32 c3
2026-05-24 optimised benchmarked
2026-05-25 discharge partial
2026-05-25 calibration
2026-05-27 esp now
2026-05-28 completed multiple connection test
2026-06-01 Data recording
2026-06-03 cleaning
2026-06-05 solar run 2
2026-06-08 broken discharge data
2026-06-14 data calibration
2026-06-16 fixed offset code (untested)
2026-06-18 update?
2026-06-22 tuned adc senser calibration
2026-06-25 recalibrate ads1115 cleaner code
